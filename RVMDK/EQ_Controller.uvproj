# Keil uVision project EQ_Controller.uvproj, settings and files
target DAQ_Project (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: EQ_Controller +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\uCOSII\CONFIG;..\uCOSII\PORT;..\uCOSII\CORE;..\FWLIB\inc;..\CMSIS;..\DRIVE;..\USER;..\Task;..\Internet;..\Ethernet;..\Ethernet\W5500;..\Internet;..\Internet\HTTP;..\Internet\DNS;..\Internet\DHCP;..\MQTT;..\Framework
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group readme
    ../: readme.txt
  group TASK
    ../Task/: Task_TCPIP.c Task_IO.c Task_Main.c Task_ModbusTCP.c Task_Main.h Task_PC_Com.c Task_MB_RTU_Master.c Task_Freq_Convert.c
  group Framework
    ../Framework/: platform_cfg.h main.c main.h framework.c framework.h interface.c interface.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h variable.c variable.h
  group DRIVE
    ../DRIVE/: DrFlash.c DrFlash.h DrTimer.c DrTimer.h DrGpio.c DrGpio.h DrSpi.c DrSpi.h DrEthernet.c DrUart.c DrCan.c DrAdc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../CMSIS/startup/: startup_stm32f10x_cl.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../CMSIS/: cortexm3_macro.s
  group uCOS
    ../UCOSII/CONFIG/: includes.h os_cfg.h
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Ethernet
    ../Ethernet/: wizchip_conf.c socket.c spi.c
    ../Ethernet/W5500/: w5500.c
